# Keil uVision project iSO-STM32.uvproj, settings and files
target uCOS-LED（多任务） (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\App;..\..\User;..\..\uCOS-III\Source;..\..\uCOS-III\Ports;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\Cfg;..\..\uCOS-III\uC-LIB;..\..\Bsp\inc;..\..\UGUI;..\..\System\delay;..\..\System\sys;..\..\System\ascii;..\..\System\crc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../Bsp/src/: bsp.c
  group App
    ../../App/: app.c app.h app_cfg.h os_cfg.h os_cfg_app.h
  group Bsp
    ../../Bsp/src/: bsp_led.c bsp_gpio_spi.c bsp_ili9341_lcd.c bsp_touch.c bsp_ili93xx.c bsp_sram.c bsp_usart.c bsp_flash.c bsp_spi.c bsp_key.c
  group uC\Source
    ../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC\Ports
    ../../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC\Lib
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_cfg.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC\Cpu
    ../../uCOS-III/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cfg.h cpu_core.c cpu_core.h cpu_def.h
  group uC\Cfg
    ../../uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h os_cfg_app.h os_cfg.h
  group uGUI
    ../../UGUI/: ugui _port.c ugui.c ugui_demo .c
  group System
    ../../System/ascii/: asciilib.c
    ../../System/delay/: delay.c
    ../../System/sys/: sys.c
    ../../System/crc/: crc16.c
